# Keil uVision project kernel.uvproj, settings and files
target uCOS-II OS (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: kernel +hex
  c flags: Optimize=8
  group kernel
    ./src/kernel/: OS_TIME.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_CORE.C
  group includes
    ./src/include/: UCOS_II.H OS_CFG.H OS_CPU.H INCLUDES.H
  group arch
    ./src/arch/: OS_CPU_A.ASM OS_CPU_C.C
  group init
    ./src/init/: TASKS.C
  group lists
    ./bin/lst/: kernel.m51 OS_CORE.lst OS_CPU_A.lst OS_CPU_C.lst TASKS.lst OS_SEM.lst OS_TASK.lst OS_TIME.lst OS_MUTEX.lst OS_MBOX.lst OS_FLAG.lst
  group system files
    ./src/system/: STARTUP.A51
